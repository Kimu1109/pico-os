# Repository Kimu1109/pico-os

File README.md:

# pico-os

Raspberry Pi Pico 2 W(RP2350)の上で動く、自作のタッチ操作GUI OS。
PlatformIO + Arduino の C++ で書かれ、240x320のTFT液晶とタッチパネルで操作する。
同じソースをPC(SDL2)とブラウザ(WebAssembly)でも動かせる。

- **ブラウザで試す**: <https://kimu1109.github.io/pico-os/>(Web版本体は `/playground/`)
- **Lua APIの説明**: <https://kimu1109.github.io/pico-os/lua-api/>

## できること

- **自前のGUIフレームワーク** — ウィジェット・シーン・ダイアログ・オンスクリーンキーボード(日本語かな漢字変換つき)。PICO-8風の16色パレットとダークテーマ
- **標準アプリ** — Markdown/Webブラウザ、時計・アラーム・タイマー、電卓、ファイル、テキストエディタ、メモ、カレンダー、TODO、チャット、メール、辞書、読書(青空文庫)、SSH、ミュージック、動画、ゲームボーイエミュレータ など
- **Luaアプリ** — SDカードの `lua/apps/<名前>/main.lua` を置くだけでホーム画面に並ぶ。`pico.*` API(描画・SD・ネットワーク・ゲーム・2.5Dエンジン等)とアプリストア
- **OSの機能** — Wi-Fiの管理(保存済み・固定IP・mDNS・スマホからの設定)、通知、バックグラウンド実行、画面ロック、自動調光とスリープ、スクリーンショット、Wi-Fi経由のファーム更新
- **音** — I2S出力のチップチューン音源・MML・WAV、I2Sマイクでの録音
- **入力** — タッチのほか、物理キーボード(CardKB2・USBシリアル)とWiiクラシックコントローラー
- **開発者向けの道具** — プロファイラ、Luaデバッガ、クラッシュダンプ、自己診断

進み具合は [`SUMMARY.md`](SUMMARY.md)、機能ごとの設計は [`docs/design/`](docs/design/) にある。

## ハードウェア

| 項目 | 部品 |
|---|---|
| マイコン | Raspberry Pi Pico 2 W(RP2350) |
| 画面 / タッチ | 240x320 TFT(LovyanGFX)/ XPT2046 |
| ストレージ | microSDカード(SPI1、SdFat) |
| 音声出力 | MAX98357A(I2S)。イヤホン用にPCM5102Aを並べられる |
| マイク | SPH0645(I2S) |
| I2C | Wiiクラシックコントローラー・CardKB2 |

ピン配置は [`CLAUDE.md`](CLAUDE.md)「ハードウェア構成」を見ること。液晶・タッチ・SDは必須で、音声・マイク・電池などはビルド時に外せる
(例は `buildcfg/variants.ini` の `rpipico2w_minimal`)。320x480の液晶向けの設定(`rpipico2w_320x480`)もある。

## ビルド

### 実機(PlatformIO)

```sh
pio run -e rpipico2w                # ビルド
pio run -e rpipico2w -t upload      # USBで書き込み
pio run -e rpipico2w -t fwpush --upload-port picoos.local   # Wi-Fi経由で更新
```

ファームの更新の流れは [`docs/guide/FIRMWARE_UPDATE.md`](docs/guide/FIRMWARE_UPDATE.md)。

### PC / Web

実機が無くても、PC上のウィンドウやブラウザで同じものが動く。必要なのは CMake・C++17のコンパイラ・SDL2・OpenSSL。

```sh
cmake -S pc -B pc/build && cmake --build pc/build -j
python3 script/release/build_app_repo.py fetch   # 標準のLuaアプリをアプリストアから取って sdcard/ へ(任意)
./pc/build/picoos_pc
```

`sdcard/` がSDカードの中身として使われる。詳しくは [`pc/README.md`](pc/README.md)(WebAssemblyは [`docs/design/pc-web.md`](docs/design/pc-web.md))。

### テスト

```sh
sh script/host_test/run.sh          # ホストテスト(CMake + CTest、ASan)
python3 script/check/check_layers.py      # include の層の決まりを確かめる
```

開発用のスクリプトは `cli-tool/picoos` から名前で呼べる(`sh cli-tool/install.sh` で `~/.local/bin` へリンク、使い方は `picoos --help`)。

## ディレクトリ

| 場所 | 中身 |
|---|---|
| `src/` | OS本体(`system/` `hal/` `services/` `gui/` `apps/` `lua/` ほか) |
| `lib/` | 同梱ライブラリ(Lua 5.4.7・Monocypher・Peanut-GB・QR Code generator) |
| `pc/` | PC/Webビルド。`sdcard/` はSDカードの中身の見本 |
| `script/` | アイコン・画像・辞書の生成、ホストテスト、層の検査など |
| `docs/` | 通信・ファイル形式の仕様と、`docs/design/` の設計記録 |
| `lua-api-doc/` | Lua APIの利用者向けドキュメント(Hugo) |
| `server/chat/` | チャットアプリ用の自前サーバ |

標準のLuaアプリ(テトリス・ペイント等)の正本とLuaアプリの配布元(アプリストア)は別リポジトリ [kimu1109/pico-os-apps](https://github.com/kimu1109/pico-os-apps)。

## Claude Code との開発

このリポジトリは [Claude Code](https://claude.com/claude-code)(Anthropic のAIコーディングエージェント)と一緒に開発している。
多くのコミットとプルリクエストは Claude Code が作成し、コミットには `Co-Authored-By: Claude ...` の行が付く。

Claude Code 向けの決まりはリポジトリの中に置いてある:

- [`CLAUDE.md`](CLAUDE.md) — Claude Code が毎回読み込むプロジェクトの地図と決まり(層の規則、メモリ管理、文字列、コメントは日本語 など)。人が全体像を掴むのにも使える
- [`.claude/settings.json`](.claude/settings.json) / [`.claude/hooks/session-start.sh`](.claude/hooks/session-start.sh) — Claude Code on the web のセッション開始時に、PlatformIO・SDL2などを入れて実機ビルドとPCビルドをすぐ回せる状態にするフック
- [`docs/design/`](docs/design/) — 機能ごとの設計の背景と経緯。Claude Code はここを引いて作業する

実機を人が触らないと確かめられない項目は [`docs/guide/HARDWARE_CHECKLIST.md`](docs/guide/HARDWARE_CHECKLIST.md) に手順を残している。

## ライセンス

[MIT ライセンス](LICENSE)(Copyright (c) 2026 Kimu1109)。
同梱している他者のコード・データは、それぞれのライセンスに従う([`THIRD_PARTY_LICENSES.md`](THIRD_PARTY_LICENSES.md))。

## KiCad design hardware/carrier/pico-os-carrier.kicad_pcb

File hardware/carrier/README.md:

# pico-os キャリアボード v0.3

Raspberry Pi Pico 2 W と、今までジャンパワイヤでつないでいたモジュールを1枚の基板に載せるための基板(KiCad 8、2層)。
**基板自体はほとんど機能を持たず、モジュールをつなぐだけ**。ピンの割り当てはファームの `src/consts.hpp` と同じ。

> **今の状態: 全ネットを配線済み。DRC(回路図との照合込み)・ERC とも違反 0**(下の「配線」)。発注前に下の「確かめること」を見る。
> 部品の形とピンの並びは、商品写真・寸法図・実物で確かめた(2026-11-02)。

設計の経緯と決めたことは `docs/design/carrier-board.md`。

## ファイル

| ファイル | 中身 |
|---|---|
| `pico-os-carrier.kicad_pro` / `.kicad_sch` / `.kicad_pcb` | KiCad のプロジェクト・回路図・基板 |
| `lib/pico-os-carrier.kicad_sym` / `lib/pico-os-carrier.pretty/` | 自作の記号と部品の形(モジュール・Pico・液晶) |
| `sym-lib-table` / `fp-lib-table` | 上の自作ライブラリを `${KIPRJMOD}` から読む |
| `tools/gen_carrier.py` | 初版を生成したスクリプト(**KiCadで手直しを始めたら回さない**。手直しが消える) |
| `tools/check_pins.py` | 回路図の結線を `src/consts.hpp` と突き合わせる(回路図を直したら回す) |
| `tools/route_carrier.py` | 配線(下の「配線」) |
| `tools/export_jlcpcb.py` | JLCPCB 用のガーバー・ドリルを書き出して zip にする(下の「JLCPCB への発注」) |
| `fab/` | 発注に使う zip(版ごと) |

## 基板の形

- 外形 100 x 160 mm、2層、1.6mm。表から見て上の中央に液晶、下に Pico 2 W が横向き(USBが左、アンテナが右の切り欠き)。
  詰め込まず、モジュールどうしは 8〜12mm 前後・液晶の14ピンの列と Pico の間は約34mm 空けた(v0.3。v0.1 は 64x128、v0.2 は 80x140 で、まだ窮屈に見えた)。
  USBのケーブルはソケットで浮いた Pico の上から挿す。
- **表**: 液晶(MSP2807)だけ。14ピンと4ピン(SD)をピンソケットで受け、四隅のM3の穴(液晶の穴と同じ位置)をスペーサーで留める。
  液晶の裏のSDスロットは表から見て左の縁にあるので、液晶と基板のすき間からカードを差す。
- **裏**: Pico・LiPo SHIM・PCM5102A・MAX98357A・マイク・RTC・コネクタ・ジャンパー。
- **アンテナの下は基板を切り欠いた**(右下の切り込み)。切り込みの上下の細い所にもGNDのベタは敷かない。
- GNDのベタは両面。ネットクラスの決まり: 電源(GND/VSYS/VBUS/+3V3/LCD_VCC/PCM_VCC/GROVE_VCC)は1.0mm、ほかは0.4mm、間隔は0.3mm。

## 部品

| 番号 | 部品 | 面 | 備考 |
|---|---|---|---|
| U1 | Raspberry Pi Pico 2 W | 裏 | 1x20のピンソケット2本で抜き差し |
| U2 | LiPo SHIM for Pico(PiCoLiPoSHIM) | 裏 | Picoに重ねず、同じ番号のピンを基板で結ぶ。穴は Pico の 1〜8・33〜40番の位置。使うのは電源(36/37/39/40)とGND(3/8/33/38)だけ。**JSTとボタンの面を外へ向けて挿す** |
| U3 | MSP2807(ILI9341 2.8インチ、タッチ・SD付き) | 表 | 寸法は lcdwiki の `MSP2807_Size.pdf` |
| U4 | MAX98357A モジュール(TVETE、18x19) | 裏 | Adafruit 3006 と同じ並び(LRC/BCLK/DIN/GAIN/SD/GND/VIN、商品写真で確認)。VIN=VSYS。GAINはつながない(9dB) |
| U5 | PCM5102A モジュール(GY-PCM5102、32x17) | 裏 | 短い辺の6ピン(SCK/BCK/DIN/LCK/GND/VIN)と長い辺の9ピン(FLT/DEMP/XSMT/FMT/A3V3/AGND/ROUT/AGND/LROUT)。ジャックを右の縁に出す。**裏の H3L(XSMT)ははんだを盛らない**(GP14で動かす) |
| U6 | SPH0645LM4H ブレークアウト(Adafruit 3421、12.7x16.7) | 裏 | マイクの部品を基板側、音の穴を外へ向けて付ける(Adafruit の説明どおり「裏返し」)。外から見える面でピンの列を左にすると上から SEL/LRCL/DOUT/BCLK/GND/3V。SEL=GND |
| U7 | DS3231 + AT24C32(ZS-042、38.2x21.6) | 裏 | 6ピン(32K/SQW/SCL/SDA/VCC/GND)。ピンはチップの面から出す(**電池の面が外を向く**ので電池を替えやすい)。VCC=3.3V |
| J1 | CardKB2 用 Grove(JST PH 4ピン、HY2.0の代わり) | 裏 | 1=黒GND 2=赤VCC 3=黄SDA 4=白SCL。**差す前にケーブルの色と並びを確かめる** |
| J2 | Qwiic(Wiiヌンチャク変換基板) | 裏 | GND/3V3/SDA/SCL。**利用者の組み立てでは付けない**(DS3231 の4ピン側からジャンパワイヤでつなぐ。下の「確かめること」) |
| J3 | イヤホンの差し込み検出(GP8・GND) | 裏 | ジャックの検出接点をここへ配線する(差すとGNDへ落ちる向き) |
| JP1〜3 | 液晶・PCM5102A・CardKB2 の電源の選択 | 裏 | 既定は 1-2(3.3V)。2-3 にすると VSYS |
| JP4 | Groveの白線 | 裏 | 既定は 1-2(SCL、I2Cモード)。UARTモードは 2-3(GP7) |
| JP5 | Groveの黄線をSDAへ | 裏 | 既定はつなぐ。UARTモードでは切る |
| JP6 | アンプの検出(GP5をGNDへ) | 裏 | 既定はつなぐ。アンプを載せないなら切る |
| R1, R2 | I2Cのプルアップ 4.7k | 裏 | 普段は載せない(モジュールにある) |
| C1 | 100uF 10V(VSYS) | 裏 | 電池で鳴らしたときの音割れ対策 |

スピーカーはMAX98357Aの端子台へ直接つなぐ(基板には端子を設けない)。電池はSHIMのJSTへ差す。

## 配線

`tools/route_carrier.py`(KiCad の Python だけで動く格子の迷路探索)で全ネットを引いた。小さくするより確実に動くことを優先し、余裕を持たせた:

| | 値 |
|---|---|
| 信号の線 | 0.5mm |
| 電源の線(VSYS/VBUS/+3V3 など) | 1.0mm(Qwiic の細い端子へ入る所と、通れなかった LCD_VCC/PCM_VCC/GROVE_VCC の枝は 0.5mm) |
| 銅どうしの間隔 | 0.5mm(Qwiic の 1mm 間隔の端子の周りだけ 0.4mm。DRC の決まりは 0.4mm)。空きがあれば別のネットから 1.5mm 以上離れた所を通す |
| 基板の縁から | 1.5mm |
| ビア | 外径0.8mm・穴0.4mm |
| 層の使い方 | 表は横、裏は縦を主に使う |

GND は両面のベタと 0.5mm の線の両方でつないだ。端子の上と近くにはビアを置かない。線で区切られたベタの島に掛かる GND の端子は、ベタへ全面でつないだ(サーマルの橋が島に掛かる警告を消すため)。

液晶を留める M3 の穴の周り(半径3.5mm)は、スペーサーとネジ頭の下になるので線とビアを通していない(GND のベタだけ)。
Grove(J1)と Qwiic(J2)の差し口は基板の右の縁を向く。シルクは文字の高さ 1mm 以上・線 0.15mm 以上(JLCPCB の目安)。

手で直すときは KiCad で `pico-os-carrier.kicad_pcb` を開き、直した後に

1. `B` キーでベタを埋め直し、DRC(回路図との照合を入れて)を通す。
2. `python3 hardware/carrier/tools/check_pins.py` で結線がファームと合っているかを見る。

**手で直し始めたら `gen_carrier.py` / `route_carrier.py` は回さない**(配置と配線が作り直しになる)。
作り直すときの順は `gen_carrier.py` → `route_carrier.py`(数回やり直して全部つながった回を残す。十数分かかる)→ `export_jlcpcb.py`。

## JLCPCB への発注

`python3 hardware/carrier/tools/export_jlcpcb.py` で `fab/pico-os-carrier-v<版>-jlcpcb.zip` を作る(ガーバー7枚・PTH/NPTH のドリル・穴の地図)。
JLCPCB の注文画面で zip を上げ、次のように選ぶ(ほかは既定のまま):

| 項目 | 値 |
|---|---|
| Layers | 2 |
| Dimensions | 100 x 160 mm(zip から自動で読まれる) |
| PCB Thickness | 1.6 mm |
| Surface Finish | HASL(鉛フリーでも可) |
| Outer Copper Weight | 1 oz |
| Min via hole size/diameter | 0.3mm/(0.4/0.45mm) 以上なら何でもよい(この基板のビアは 0.4/0.8mm) |
| Remove Order Number | 好みで(番号を入れたくなければ指定する) |

穴を2列の端子の間に置いていないので、どの設定でも追加の費用は掛からない見込み。部品の実装(PCBA)は頼まない前提。

## 確かめること(実物でしか分からないもの)

- **LiPo SHIM の向き**: 文字の面が Pico の裏と向き合う(Pimoroni の説明)ことと、JST・ボタンが文字の無い面にある(商品写真)ことから、
  部品面から見た穴の並びを Pico の鏡映にした。**逆に挿すと VBUS/VSYS が GP0〜GP5 につながる**ので、キャリアボードに印刷した
  「BTN」(ボタンの端)「JST」(電池コネクタの端)に合わせ、ボタンと電池コネクタの面を外に向けて挿す。SHIM 自体の「+」「-」は電池の極性の表示。
  ピンは文字の面から出す(部品の面を上にしてブレッドボードに挿せる向き)。利用者の物はこの向き(2026-11-03 に確認)。
- **DS3231 のピンの向き**: 商品写真の物は **L字のピン**が付いている。この基板は「まっすぐなピンをチップの面から出し、電池の面を外へ向ける」形なので、
  届いたら L字のピンを外してまっすぐなピンに付け替える(2026-11-03 に決めた。基板はそのまま使える)。
- **Wii の変換基板は J2 を使わずジャンパワイヤでつなぐ**(2026-11-12 に利用者と決めた。SH 4ピンの表面実装コネクタが手に入りにくいため)。
  DS3231 の反対の端の4ピン(SCL/SDA/VCC/GND。I2C がそのまま出ている。VCC は 3.3V)と変換基板の同じ名前の端子を結ぶ。
  キャリアボードには DS3231 の4ピン側の穴が無いので、4ピン側のピンは**電池の面から上へ出す**(下向きに付けると基板に当たって浮く)。
- PCM5102A は商品写真から読んだ位置なので、端子の位置(左の列は縁から約1.3mm、上の列は左の縁から約7mm)を実物で測っておくと安心。
- PCM5102A のジャック(PJ-327A)の1番(差し込み検出の接点と思われる)はモジュールの上でどこにもつながっていない。イヤホンの自動切り替えに使うなら、ここから J3 へ線を引けるか実物で確かめる。
- ZS-042 は CR2032 を充電する回路(ダイオードと抵抗)が付いていることが多い。CR2032を使うなら外す。
- 確認済み(2026-11-03、利用者): PCM5102A の H3L にはんだは盛られていない。マイクは文字(SEL〜3V)の面が外、ピンはマイク本体の面から出ている。
  Pico 2 W は **WH(ピンヘッダ付き)**。ピンは下向きで、黒いサポート材は2列の間なのでソケットに当たらない。デバッグ用の3ピンは付けていない
  (WH のデバッグ用コネクタは表の面にあるので基板に当たらない)。
- 電源ボタン(SHIM)で切れるのは 3V3_EN だけ。VSYS につながる物(MAX98357A・C1・JPでVSYSを選んだ物)は電池につながったまま。

Parts:
C1: 100uF 10V; CP_Elec_6.3x5.4
J1: CardKB2 (Grove/HY2.0); JST_PH_S4B-PH-K_1x04_P2.00mm_Horizontal
J2: Qwiic (Wii adapter); JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal
J3: HP_DET; PinHeader_1x02_P2.54mm_Vertical
JP1: LCD_VCC 3V3|VSYS; SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm
JP2: PCM_VCC 3V3|VSYS; SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm
JP3: GROVE_VCC 3V3|VSYS; SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm
JP4: GROVE_W SCL|GP7; SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm
JP5: GROVE_Y SDA; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
JP6: AMP_DET; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
R1, R2: 4.7k; R_0805_2012Metric; not fitted
U1: Raspberry Pi Pico 2 W; RaspberryPi_Pico2W_Socket
U2: LiPo SHIM for Pico; Pimoroni_LiPo_SHIM
U3: MSP2807 (ILI9341 2.8inch); MSP2807_LCD
U4: MAX98357A module; MAX98357A_Module
U5: PCM5102A module (GY-PCM5102); PCM5102A_Module
U6: SPH0645LM4H breakout (Adafruit 3421); SPH0645_Module
U7: DS3231 module (ZS-042); DS3231_ZS042_Module

Connections:
/3V3_EN: U1.37 (3V3_EN), U2.37 (3V3_EN)
/+3V3: J2.2, JP1.1 (A), JP2.1 (A), JP3.1 (A), R1.1, R2.1, U1.36 (3V3), U2.36 (3V3), U6.1 (3V), U7.5 (VCC)
/AMP_DET: JP6.1 (A), U1.7 (GP5)
/AMP_SD: U1.9 (GP6), U4.5 (SD)
/CARDKB_RX: JP4.3 (B), U1.10 (GP7)
/GND: C1.2, J1.1, J2.1, J2.MP (MountPin), J3.2, JP6.2 (B), U1.3 (GND), U1.8 (GND), U1.13 (GND), U1.18 (GND), U1.23 (GND), U1.28 (GND), U1.33 (AGND), U1.38 (GND), U2.3 (GND), U2.8 (GND), U2.33 (AGND), U2.38 (GND), U3.2 (GND), U4.6 (GND), U5.1 (SCK), U5.5 (GND), U5.7 (FLT), U5.8 (DEMP), U5.10 (FMT), U5.12 (AGND), U5.14 (AGND), U6.2 (GND), U6.6 (SEL), U7.6 (GND)
/GROVE_VCC: J1.2, JP3.2 (C)
/GROVE_W: J1.4, JP4.2 (C)
/GROVE_Y: J1.3, JP5.2 (B)
/HP_DET: J3.1, U1.11 (GP8)
/HP_MUTE: U1.19 (GP14), U5.9 (XSMT)
/I2C_SCL: J2.4, JP4.1 (A), R2.2, U1.2 (GP1), U7.3 (SCL)
/I2C_SDA: J2.3, JP5.1 (A), R1.2, U1.1 (GP0), U7.4 (SDA)
/I2S_BCLK: U1.4 (GP2), U4.2 (BCLK), U5.2 (BCK)
/I2S_DIN: U1.6 (GP4), U4.3 (DIN), U5.3 (DIN)
/I2S_LRCLK: U1.5 (GP3), U4.1 (LRC), U5.4 (LCK)
/LCD_VCC: JP1.2 (C), U3.1 (VCC)
/MIC_BCLK: U1.31 (GP26), U6.3 (BCLK)
/MIC_DOUT: U1.34 (GP28), U6.4 (DOUT)
/MIC_LRCLK: U1.32 (GP27), U6.5 (LRCL)
/PCM_VCC: JP2.2 (C), U5.6 (VIN)
/SD_CS: U1.20 (GP15), U3.15 (SD_CS)
/SD_MISO: U1.16 (GP12), U3.17 (SD_MISO)
/SD_MOSI: U1.15 (GP11), U3.16 (SD_MOSI)
/SD_SCK: U1.14 (GP10), U3.18 (SD_SCK)
/SPI0_MISO: U1.21 (GP16), U3.9 (SDO), U3.13 (T_DO)
/SPI0_MOSI: U1.25 (GP19), U3.6 (SDI), U3.12 (T_DIN)
/SPI0_SCK: U1.24 (GP18), U3.7 (SCK), U3.10 (T_CLK)
/TFT_CS: U1.22 (GP17), U3.3 (CS)
/TFT_DC: U1.26 (GP20), U3.5 (DC)
/TFT_LED: U1.29 (GP22), U3.8 (LED)
/TFT_RST: U1.27 (GP21), U3.4 (RESET)
/TOUCH_CS: U1.17 (GP13), U3.11 (T_CS)
/TOUCH_IRQ: U1.12 (GP9), U3.14 (T_IRQ)
/VBUS: U1.40 (VBUS), U2.40 (VBUS)
/VSYS: C1.1, JP1.3 (B), JP2.3 (B), JP3.3 (B), U1.39 (VSYS), U2.39 (VSYS), U4.7 (VIN)

Notes on the sheet:
pico-os キャリアボード v0.1(配線前の初版)。同じ名前のラベルどうしがつながる。
仮のもの: U4 MAX98357A・U5 PCM5102A・U6 SPH0645・U7 DS3231 のピンの並びと外形は写真で確かめて直す。
ジャンパーの既定: JP1/JP2/JP3=3.3V、JP4=SCL(I2Cモード)、JP5=つなぐ、JP6=つなぐ(GP5をGNDへ)。
CardKB2をUARTモードで使うとき: JP4を2-3(GP7)へ、JP5を切る。
SHIMの電源ボタンが切るのは3V3_ENだけ。VSYS(アンプ・C1)は電池につながったまま。

Board: 2 copper layers, 100.0 x 160.0 mm, 19 parts (18 on the bottom side), 36 nets.

## Code that names these connections

File script/host_test/hw_config_test.cpp (part):

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    check(!validate(c, &why) && why.find("lcd.sck") != std::string::npos, "SPI0のSCKに使えないピンを弾く");

    c = def;
    c.sd_miso = 16;
    check(!validate(c, &why) && why.find("sd.miso") != std::string::npos, "SPI1のMISOに使えないピンを弾く");

    c = def;
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    check(!validate(c), "SDの速さの下限");

    c = def;
    c.sd_sck = 14; c.sd_mosi = 15; c.sd_miso = 12; c.sd_cs = 10;
    check(validate(c), "SPI1の別の端子の組は使える");
}

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
    c.lcd_hz = 40000000;
    c.lcd_offset_y = 80;
    c.sd_cs = 7;
    n = Encode(c, buf, sizeof(buf));
    const std::string body(reinterpret_cast<const char*>(buf + kHeaderBytes), n - kHeaderBytes);
    check(body == "lcd.hz=40M\nlcd.offset_y=80\nsd.cs=7\n", "既定と違うキーだけを書く");
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    check(Crc32(reinterpret_cast<const uint8_t*>("123456789"), 9) == 0xCBF43926u, "CRC32の検査値");

    HwConfig a = HwConfigDefault(), b = HwConfigDefault();
    b.sd_cs = 7;
    check(SameGroup(a, b, Group::Lcd) && !SameGroup(a, b, Group::Sd), "SameGroup はその部分だけ比べる");
    CopyGroup(a, b, Group::Sd);
    check(a.sd_cs == 7, "CopyGroup");
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